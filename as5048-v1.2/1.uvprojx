# Keil uVision project 1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWlib\inc;.\StartUp;.\System;.\User;D:\keil514\ARM\ARMCC\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --libpath=D:\keil514\ARM\ARMCC\lib
--libpath=E:\Keil_v5\ARM\ARMCC\lib
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group System
    ./System/: delay.c I2C.c sys.c as5600.c usart.c timer.c
  group User
    ./User/: main.c stm32f10x_it.c
